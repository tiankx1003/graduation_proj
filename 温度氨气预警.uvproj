# Keil uVision project 温度氨气预警.uvproj, settings and files
target 目标 1 (MCS-51)
  device: Core8051 Actel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: 温度氨气预警 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 lcd.c main.c XPT2046.c temp.c
